# Keil uVision project dem_san_pham_LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: dem_san_pham_LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LIB_lcd_8051.h LIB_lcd_8051.c Port_lcd_4bit.h
